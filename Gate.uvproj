# Keil uVision project Gate.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Gate +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\GATE;.\STM32F0xx_AN4055_V1.0.1;.\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MAIN
    ./: system_stm32f10x.c main.cpp TaskManager.cpp TaskManager.h General.c startup_stm32f10x_hd.s
  group Library
    ./Library/: RTX_CM3.lib
  group Config
    ./Config/: RTX_Conf_CM.c
  group GATE
    ./: Gate.cpp
  group CMSIS
    ./STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c
  group MANAGE
    ./: Manage.cpp Master.cpp Master.h
